# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx
  c misc: --diag_suppress=188,546,68,111,USE_HAL_DRIVER,
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers;../../Template;../Middlewares;../Middlewares/SCPI/inc;../Middlewares/SCPI/common;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Task;../Middlewares/LVGL;../Middlewares/LVGL/examples/porting;../Middlewares/LVGL/src;../GUI/GUI_APP;../GUI/GUI_APP/custom;../GUI/GUI_APP/generated;../GUI/GUI_USER;..\GUI\GUI_Btn;..\User;..\..\ZDYZ_CAN_RTOS_3.9
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT1: ROM 0x90002000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c dma2d.c fdcan.c fmc.c ltdc.c quadspi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/MPU/: mpu.c
    ../Drivers/BSP/Touch/: ctiic.c Touch.c
  group Middlewares/SCPI_lib
    ../Middlewares/SCPI/src/: error.c expression.c fifo.c ieee488.c lexer.c minimal.c parser.c units.c utils.c
  group Middlewares/SCPI_APP
    ../Middlewares/SCPI/common/: scpi-def.c scpi-port.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Task
    ../Task/: Gui_Task.c
  group Middlewares/LVGL_Port
    ../Middlewares/LVGL/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../Middlewares/LVGL/: lv_conf.h
  group Middlewares/LVGL
    ../Middlewares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middlewares/LVGL/src/extra/: lv_extra.c
    ../Middlewares/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group GUI/APP
    ../GUI/GUI_APP/generated/: gui_guider.h events_init.c gui_guider.c widgets_init.c setup_scr_Back.c setup_scr_HOME_PAGE.c setup_scr_HOME_MENU.c setup_scr_Menu_Config.c setup_scr_Menu_Measure.c setup_scr_Menu_Meter.c setup_scr_Menu_Protect.c setup_scr_Menu_Recall.c setup_scr_Menu_Recorder.c setup_scr_Menu_Save.c setup_scr_Menu_Trigger.c setup_scr_Menu_Admin.c setup_scr_Menu_Communication.c setup_scr_Menu_Coupling.c setup_scr_Menu_Date.c setup_scr_Menu_Delays.c setup_scr_Menu_Digital_IO.c setup_scr_Menu_Energy.c setup_scr_Menu_Function.c setup_scr_Menu_General.c setup_scr_Menu_Group.c setup_scr_Menu_Info.c setup_scr_Menu_Log.c setup_scr_Menu_Preference.c
    ../GUI/GUI_APP/custom/: custom.c
  group GUI/Img
    ../GUI/GUI_APP/generated/images/: _admin_alone_alpha_70x70.c _base3_95x95.c _beep_alpha_32x30.c _communication_alone_alpha_70x70.c _config_alone_alpha_70x70.c _coupling_alone_alpha_70x70.c _date_alone_alpha_70x70.c _delays_alone_alpha_70x70.c _Digital_io_alone_alpha_70x70.c _energy_alone_alpha_70x70.c _Function_alone_alpha_70x70.c _general_alone_alpha_70x70.c _group_alone_alpha_70x70.c _Icons_Menu_alpha_46x44.c _info_alone_alpha_70x70.c _keyback_alpha_245x40.c _kk_alpha_37x36.c _log_alone_alpha_70x70.c _Logo_alpha_569x159.c _measure_alone_alpha_70x70.c _meter2_alpha_70x70.c _perfect_alone_alpha_70x70.c _protect_alone_alpha_70x70.c _recall_alone_alpha_70x70.c _recoder_alone_alpha_70x70.c _save_alone_alpha_70x70.c _suo_alpha_30x30.c _trigger_alone_2_alpha_70x70.c _usb3_alpha_47x34.c _back1_alpha_60x60.c _home_alpha_60x60.c
  group GUI/Font
    ../GUI/GUI_APP/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_23.c lv_font_SourceHanSerifSC_Regular_30.c lv_font_SourceHanSerifSC_Regular_35.c lv_font_SourceHanSerifSC_Regular_40.c lv_font_SourceHanSerifSC_Regular_110.c lv_font_SourceHanSerifSC_Regular_140.c
    ../GUI/GUI_USER/: MultString.c
  group GUI/User
    ../GUI/GUI_USER/: HomePage.c HomePage_LED.c Home_Menu.c Menu_Config.c Menu_Protect.c Menu_Measure.c Menu_Meter.c Menu_Recall.c Menu_Recorder.c Menu_Save.c Menu_Trigger.c MultString.c Menu_Admin.c Menu_Communication.c Menu_Coupling.c Menu_Date.c Menu_Delays.c Menu_Digital_IO.c Menu_Energy.c Menu_Function.c Menu_General.c Menu_Group.c Menu_Info.c Menu_Log.c Menu_Preference.c
  group GUI/Btn
    ../GUI/GUI_Btn/: Tree.c BtnTree.c
  group User
    ../User/: power_interface.c power_interface.h
  group CAN
    ../CAN/: can.c can_manager.c can_manager.h
software components: CMSIS:CORE 4.3.0
